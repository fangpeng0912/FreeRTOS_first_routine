# Keil uVision project FreeRTOS_first_routine.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRTOS_first_routine +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\RTE;.\freeRTOS\include;.\freeRTOS\portable\RVDS\ARM_CM3;.\StdPeriph Driver\inc;.\app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ./app/: main.c led.c RS232.c
  group FreeRTOS_CORE
    ./freeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ./freeRTOS/portable/MemMang/: heap_4.c
    ./freeRTOS/portable/RVDS/ARM_CM3/: port.c
  group StdPeriph Driver
    ./StdPeriph Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
